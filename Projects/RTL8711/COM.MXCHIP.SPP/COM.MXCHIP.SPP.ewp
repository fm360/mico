# IAR project COM.MXCHIP.SPP.ewp, settings and files
configuration EMW3081 (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CONFIG_PLATFORM_8195A; DEBUG; ZC_MODULE_VERSION=0; ZC_MODULE_TYPE=5; ZC_MODULE_DEV; ZC_EASY_UART; TEST_ADDR; AIRKISS_DISCOVERY_ENABLE
  ICCARM.CCDiagSuppress: Be006,Pa050,Pa039,Pa089,Pe014,Pe047,Pe068,Pe089,Pe167,Pe177,Pe186,Pe188,Pe375,Pe550,Pe550,Pe223,Pe549,Pe550
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\soc\realtek\common\bsp; ..\..\..\component\soc\realtek\8195a\misc\driver; ..\..\..\component\common\api\network\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8195a; ..\..\..\component\soc\realtek\8195a\cmsis; ..\..\..\component\soc\realtek\8195a\cmsis\device; ..\..\..\component\soc\realtek\8195a\fwlib; ..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\utilities; ..\..\..\component\soc\realtek\8195a\misc\rtl_std_lib\include; ..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\include; ..\..\..\MICO; ..\..\..\Support; ..\..\..\External; ..\..\..\Board\EMW3081; ..\..\..\Platform\include; ..\..\..\Platform\Cortex-M3; ..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\Platform\MCU\RTL8711\peripherals; ..\..\..\Platform\Drivers\spi_flash; ..\..\..\Platform; ..\..\..\Platform\MCU; ..\..\..\Demos\COM.MXCHIP.SPP\AC\inc; ..\..\..\Demos\COM.MXCHIP.SPP\ZC\inc\aes; ..\..\..\Demos\COM.MXCHIP.SPP\ZC\inc\tropicssl; ..\..\..\Demos\COM.MXCHIP.SPP\ZC\inc\zc; ..\..\..\Demos\COM.MXCHIP.SPP\Adaptor
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc; ..\..\..\component\soc\realtek\8195a\cmsis; ..\..\..\component\os\os_dep\include; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\include; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM3; ..\..\..\component\soc\realtek\8195a\misc\driver; ..\..\..\component\common\api\network\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\common\application\google; ..\..\..\component\common\example; ..\..\..\component\common\example\wlan_fast_connect; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8195a; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\ipv4; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek; ..\..\..\component\common\test; ..\..\..\component\soc\realtek\8195a\cmsis; ..\..\..\component\soc\realtek\8195a\cmsis\device; ..\..\..\component\soc\realtek\8195a\fwlib; ..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\utilities; ..\..\..\component\soc\realtek\common\rtl_std_lib\include; ..\..\..\..\mico\Demos\COM.MXCHIP.SPP; ..\..\..\..\mico\include; ..\..\..\..\mico\MICO; ..\..\..\..\mico\Support; ..\..\..\..\mico\External; ..\..\..\..\mico\Board\8711AM_Test; ..\..\..\..\mico\Platform\include; ..\..\..\..\mico\Platform\Cortex-M3; ..\..\..\..\mico\Platform\Cortex-M3\CMSIS; ..\..\..\..\mico\Platform\MCU\RTL8711\peripherals; ..\..\..\..\mico\Platform\Drivers\spi_flash; ..\..\..\..\mico\Platform; ..\..\..\..\mico\Platform\MCU
  OBJCOPY.OOCOutputFile: COM.MXCHIP.SPP.bin
  prebuild: CSCRIPT  "..\..\..\component\soc\realtek\8195a\misc\iar_utility\common\prebuild.vbs" "$PROJ_DIR$"
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\8195a\misc\iar_utility\common\postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$"  "$CONFIG_NAME$"
  ILINK.IlinkOutputFile: application.axf
  ILINK.IlinkKeepSymbols: bootloader; gImage2EntryFun0; RAM_IMG2_VALID_PATTEN
  ILINK.IlinkIcfFile: E:\qe\MIKO-SDK-3081\mico.git\Board\EMW3081\micoLinkerForIAR.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect free=vPortFree; --redirect calloc=calloc_freertos; --redirect realloc=pvPortRealloc; --redirect asctime=mxchipasctime
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group APP
    ../../../Demos/COM.MXCHIP.SPP/: LocalTcpServer.c MICOAppEntrance.c MICOConfigDelegate.c RemoteTcpClient.c SppProtocol.c UartRecv.c
  group APP/AC
    ../../../Demos/COM.MXCHIP.SPP/AC/src/: ac_api.c ac_hal.c
  group APP/ZC
    ../../../Demos/COM.MXCHIP.SPP/ZC/src/aes/: aes_cbc.c aes_core.c
    ../../../Demos/COM.MXCHIP.SPP/ZC/src/tropicssl/: bignum.c rsa.c
    ../../../Demos/COM.MXCHIP.SPP/ZC/src/crc/: crc.c
    ../../../Demos/COM.MXCHIP.SPP/ZC/src/zc/: zc_bc.c zc_client_manager.c zc_cloud_event.c zc_common.c zc_configuration.c zc_message_queue.c zc_moudle_manager.c zc_protocol_controller.c zc_sec_engine.c zc_timer.c
    ../../../Demos/COM.MXCHIP.SPP/Adaptor/: zc_mx_adpter.c
  group Board
    ../../../Board/EMW3081/: fw_loader_main.c platform.c platform.h platform_config.h
  group SDRAM/External/JSON-C
    ../../../External/JSON-C/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group SDRAM/External/SHAUtils
    ../../../External/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group SDRAM/MCU
    ../../../Platform/MCU/: mico_platform_common.c
  group SDRAM/MCU/RTL8711
    ../../../Platform/MCU/RTL8711/: platform_init.c
  group SDRAM/MCU/RTL8711/library
    ../../../component/soc/realtek/8195a/cmsis/device/: system_8195a.c
    ../../../component/soc/realtek/8195a/fwlib/ram_lib/wlan/: tcm_heap.c
  group SDRAM/MCU/RTL8711/library/api
    ../../../component/common/mbed/targets/hal/rtl8195a/: analogin_api.c dma_api.c efuse_api.c flash_api.c gpio_api.c gpio_irq_api.c i2c_api.c i2s_api.c nfc_api.c pinmap.c pinmap_common.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c sys_api.c timer_api.c us_ticker.c wdt_api.c
    ../../../component/common/mbed/common/: us_ticker_api.c wait_api.c
  group SDRAM/MCU/RTL8711/library/console
    ../../../component/common/api/at_cmd/: log_service.c
    ../../../component/soc/realtek/8195a/misc/driver/: low_level_io.c rtl_consol.c
  group SDRAM/MCU/RTL8711/library/hal
    ../../../component/soc/realtek/8195a/fwlib/src/: hal_32k.c hal_adc.c hal_gdma.c hal_gpio.c hal_i2c.c hal_i2s.c hal_mii.c hal_nfc.c hal_pcm.c hal_pwm.c hal_sdr_controller.c hal_soc_ps_monitor.c hal_ssi.c hal_timer.c hal_uart.c
    ../../../component/soc/realtek/8195a/fwlib/ram_lib/: hal_spi_flash_ram.c
  group SDRAM/MCU/RTL8711/library/lib
    ../../../component/soc/realtek/8195a/misc/bsp/lib/common/IAR/: lib_platform.a lib_rtlstd.a lib_wlan.a
    ../../../component/soc/realtek/8195a/misc/bsp/lib/va0/: rom.a
  group SDRAM/MCU/RTL8711/library/rtl8195a
    ../../../component/soc/realtek/8195a/fwlib/rtl8195a/src/: rtl8195a_adc.c rtl8195a_gdma.c rtl8195a_gpio.c rtl8195a_i2s.c rtl8195a_nfc.c rtl8195a_pwm.c rtl8195a_ssi.c rtl8195a_timer.c rtl8195a_uart.c
  group SDRAM/MCU/RTL8711/Peripherals
    ../../../Platform/MCU/RTL8711/peripherals/: platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_pwm.c platform_rng.c platform_rtc.c platform_spi.c platform_uart.c platform_watchdog.c
  group SDRAM/MICO
    ../../../MICO/: MICOCli.c MICOConfigMenu.c MICOConfigServer.c MICOEntrance.c MICOForceOTA.c MICOMfgtest.c MICONotificationCenter.c MICONTPClient.c MICOParaStorage.c MICOSystemMonitor.c
    ../../../MICO/tftp/: tftpc.o
  group SDRAM/MICO/AirKiss
    ../../../MICO/Airkiss/: Airkiss.c Airkiss_CM3_Debug.a airkiss_discovery.c libairkiss.a
  group SDRAM/MICO/EasyLink
    ../../../MICO/EasyLink/: EasyLink.c
    ../../../MICO/SoftAP/: EasyLinkSoftAP.c
  group SDRAM/MICO/Library
    ../../../MICO/Library/: MICOConfig.c mxchipWNET_3081.a
  group SDRAM/MICO/Support
    ../../../Support/: AESUtils.c CheckSumUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
    ../../../Demos/COM.MXCHIP.SPP/: MICOBonjour.c
  group SDRAM/MICO/WAC
    ../../../MICO/WAC/: MFi_WAC_CM3_Debug.a
