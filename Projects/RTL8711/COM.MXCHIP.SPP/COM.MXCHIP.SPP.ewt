<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>EMW3081</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>APP</name>
    <group>
      <name>AC</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\AC\src\ac_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\AC\src\ac_hal.c</name>
      </file>
    </group>
    <group>
      <name>ZC</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\ZC\src\aes\aes_cbc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\ZC\src\aes\aes_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\ZC\src\tropicssl\bignum.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\ZC\src\crc\crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\ZC\src\tropicssl\rsa.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\ZC\src\zc\zc_bc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\ZC\src\zc\zc_client_manager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\ZC\src\zc\zc_cloud_event.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\ZC\src\zc\zc_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\ZC\src\zc\zc_configuration.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\ZC\src\zc\zc_message_queue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\ZC\src\zc\zc_moudle_manager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\Adaptor\zc_mx_adpter.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\ZC\src\zc\zc_protocol_controller.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\ZC\src\zc\zc_sec_engine.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\ZC\src\zc\zc_timer.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\LocalTcpServer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\MICOAppEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\MICOConfigDelegate.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\RemoteTcpClient.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\SppProtocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\UartRecv.c</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Board\EMW3081\fw_loader_main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Board\EMW3081\platform.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Board\EMW3081\platform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Board\EMW3081\platform_config.h</name>
    </file>
  </group>
  <group>
    <name>SDRAM</name>
    <group>
      <name>External</name>
      <group>
        <name>JSON-C</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\External\JSON-C\arraylist.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\External\JSON-C\debug.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_object.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_tokener.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_util.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\External\JSON-C\linkhash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\External\JSON-C\printbuf.c</name>
        </file>
        <configuration>
          <name>EMW3081</name>
        </configuration>
      </group>
      <group>
        <name>SHAUtils</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\External\SHAUtils\hkdf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\External\SHAUtils\hmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\External\SHAUtils\sha1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\External\SHAUtils\sha224-256.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\External\SHAUtils\sha384-512.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\External\SHAUtils\usha.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>MCU</name>
      <group>
        <name>RTL8711</name>
        <group>
          <name>library</name>
          <group>
            <name>api</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\analogin_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\dma_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\efuse_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\flash_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\gpio_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\gpio_irq_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\i2c_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\i2s_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\nfc_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\pinmap.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\pinmap_common.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\port_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\pwmout_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\rtc_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\serial_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\sleep.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\spi_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\sys_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\timer_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\us_ticker.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\common\us_ticker_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\common\wait_api.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\wdt_api.c</name>
            </file>
          </group>
          <group>
            <name>console</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\common\api\at_cmd\log_service.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\driver\low_level_io.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\driver\rtl_consol.c</name>
            </file>
          </group>
          <group>
            <name>hal</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_32k.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_adc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_gdma.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_gpio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_i2c.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_i2s.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_mii.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_nfc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_pcm.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_pwm.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_sdr_controller.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_soc_ps_monitor.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\hal_spi_flash_ram.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_ssi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_timer.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_uart.c</name>
            </file>
          </group>
          <group>
            <name>lib</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\bsp\lib\common\IAR\lib_platform.a</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\bsp\lib\common\IAR\lib_rtlstd.a</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\bsp\lib\common\IAR\lib_wlan.a</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\bsp\lib\va0\rom.a</name>
            </file>
          </group>
          <group>
            <name>rtl8195a</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_adc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_gdma.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_gpio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_i2s.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_nfc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_pwm.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_ssi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_timer.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_uart.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\cmsis\device\system_8195a.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\wlan\tcm_heap.c</name>
          </file>
        </group>
        <group>
          <name>Peripherals</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_i2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_mcu_powersave.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_pwm.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_rng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_uart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_watchdog.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\platform_init.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\MCU\mico_platform_common.c</name>
      </file>
    </group>
    <group>
      <name>MICO</name>
      <group>
        <name>AirKiss</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\MICO\Airkiss\Airkiss.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\MICO\Airkiss\Airkiss_CM3_Debug.a</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\MICO\Airkiss\airkiss_discovery.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\MICO\Airkiss\libairkiss.a</name>
        </file>
      </group>
      <group>
        <name>EasyLink</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\MICO\EasyLink\EasyLink.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\MICO\SoftAP\EasyLinkSoftAP.c</name>
        </file>
      </group>
      <group>
        <name>Library</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\MICO\Library\MICOConfig.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\MICO\Library\mxchipWNET_3081.a</name>
        </file>
      </group>
      <group>
        <name>Support</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Support\AESUtils.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Support\CheckSumUtils.c</name>
          <configuration>
            <name>EMW3081</name>
          </configuration>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Support\HTTPUtils.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Support\MDNSUtils.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\MICOBonjour.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Support\RingBufferUtils.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Support\SecurityUtils.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Support\SHAUtils.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Support\SocketUtils.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Support\StringUtils.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Support\TimeUtils.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Support\TLVUtils.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Support\URLUtils.c</name>
        </file>
      </group>
      <group>
        <name>WAC</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\MICO\WAC\MFi_WAC_CM3_Debug.a</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\MICOCli.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\MICOConfigMenu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\MICOConfigServer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\MICOEntrance.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\MICOForceOTA.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\MICOMfgtest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\MICONotificationCenter.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\MICONTPClient.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\MICOParaStorage.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\MICOSystemMonitor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\tftp\tftpc.o</name>
      </file>
    </group>
    <configuration>
      <name>EMW3081</name>
    </configuration>
  </group>
</project>


