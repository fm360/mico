<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\bootloader\Bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\COM.MXCHIP.BASIC\COM.MXCHIP.BASIC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\COM.MXCHIP.SPP\COM.MXCHIP.SPP.ewp</path>
  </project>
  <batchBuild/>
</workspace>


