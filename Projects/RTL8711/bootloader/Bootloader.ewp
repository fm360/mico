# IAR project Bootloader.ewp, settings and files
configuration EMW3081 (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CONFIG_PLATFORM_8195A; BOOTLOADER; NO_MICO_RTOS
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\Bootloader; ..\inc; ..\..\..\component\soc\realtek\common\bsp; ..\..\..\component\soc\realtek\8195a\misc\driver; ..\..\..\component\common\api\network\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8195a; ..\..\..\component\soc\realtek\8195a\cmsis; ..\..\..\component\soc\realtek\8195a\cmsis\device; ..\..\..\component\soc\realtek\8195a\fwlib; ..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\utilities; ..\..\..\component\soc\realtek\8195a\misc\rtl_std_lib\include; ..\..\..\include; ..\..\..\MICO; ..\..\..\Support; ..\..\..\External; ..\..\..\Board\EMW3081; ..\..\..\Platform\include; ..\..\..\Platform\Cortex-M3; ..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\Platform\MCU\RTL8711\peripherals; ..\..\..\Platform\Drivers\spi_flash; ..\..\..\Platform; ..\..\..\Platform\MCU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\Bootloader; ..\inc; ..\..\..\component\soc\realtek\common\bsp; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\include; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM3; ..\..\..\component\os\os_dep\include; ..\..\..\component\soc\realtek\8195a\misc\driver; ..\..\..\component\common\api\network\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\common\application\google; ..\..\..\component\common\example; ..\..\..\component\common\example\wlan_fast_connect; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8195a; ..\..\..\component\common\test; ..\..\..\component\soc\realtek\8195a\cmsis; ..\..\..\component\soc\realtek\8195a\cmsis\device; ..\..\..\component\soc\realtek\8195a\fwlib; ..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\utilities; ..\..\..\component\soc\realtek\8195a\misc\rtl_std_lib\include; ..\..\..\include; ..\..\..\MICO; ..\..\..\Support; ..\..\..\External; ..\..\..\Board\RTL8711AM; ..\..\..\Platform\include; ..\..\..\Platform\Cortex-M3; ..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\Platform\MCU\RTL8711\peripherals; ..\..\..\Platform\Drivers\spi_flash; ..\..\..\Platform; ..\..\..\Platform\MCU
  OBJCOPY.OOCOutputFile: Bootloader.bin
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\8195a\misc\iar_utility\common\postbuild_fw_loader.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$CONFIG_NAME$"
  ILINK.IlinkOutputFile: fw_loader.axf
  ILINK.IlinkKeepSymbols: bootloader
  ILINK.IlinkIcfFile: ..\..\..\Board\EMW3081\bootloaderLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Board
    ../../../Board/EMW3081/: fw_loader_main.c platform.c platform.h platform_config.h
  group Bootloader
    ../../../Bootloader/: BootloaderEntrance.c Getline.c menu.c Update_for_OTA.c ymodem.c
  group Platform
    ../../../Platform/MCU/: mico_platform_common.c
  group Platform/EWARM
    ../../../Platform/EWARM/: Retarget.c
  group Platform/RTL8711
    ../../../Platform/MCU/RTL8711/: platform_init.c
  group Platform/RTL8711/Library
    ../../../component/soc/realtek/8195a/misc/driver/: rtl_consol.c
  group Platform/RTL8711/Library/api
    ../../../component/common/mbed/targets/hal/rtl8195a/: dma_api.c flash_api.c gpio_api.c gpio_irq_api.c pinmap.c pinmap_common.c port_api.c serial_api.c sleep.c sys_api.c timer_api.c us_ticker.c
  group Platform/RTL8711/Library/hal
    ../../../component/soc/realtek/8195a/fwlib/src/: hal_gdma.c hal_gpio.c hal_sdr_controller.c hal_soc_ps_monitor.c hal_timer.c hal_uart.c
    ../../../component/soc/realtek/8195a/fwlib/ram_lib/: hal_spi_flash_ram.c
  group Platform/RTL8711/Library/lib
    ../../../component/soc/realtek/8195a/misc/bsp/lib/common/IAR/: lib_platform.a lib_rtlstd.a
    ../../../component/soc/realtek/8195a/misc/bsp/lib/va0/: rom.a
  group Platform/RTL8711/Library/rtl8195a
    ../../../component/soc/realtek/8195a/fwlib/rtl8195a/src/: rtl8195a_gdma.c rtl8195a_gpio.c rtl8195a_ssi.c rtl8195a_timer.c rtl8195a_uart.c
    ../../../component/common/api/platform/: stdlib_patch.c
  group Platform/RTL8711/Peripherals
    ../../../Platform/MCU/RTL8711/peripherals/: platform_flash.c platform_gpio.c platform_mcu_powersave.c platform_rtc.c platform_spi.c platform_uart.c platform_watchdog.c
  group Support
    ../../../Support/: CheckSumUtils.c RingBufferUtils.c StringUtils.c
