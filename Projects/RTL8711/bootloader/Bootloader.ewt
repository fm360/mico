<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>EMW3071</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>EMW3081</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Board</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Board\EMW3081\fw_loader_main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Board\EMW3081\platform.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Board\EMW3081\platform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Board\EMW3081\platform_config.h</name>
    </file>
  </group>
  <group>
    <name>Bootloader</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Bootloader\BootloaderEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Bootloader\Getline.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Bootloader\menu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Bootloader\Update_for_OTA.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Bootloader\ymodem.c</name>
    </file>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\EWARM\Retarget.c</name>
      </file>
    </group>
    <group>
      <name>RTL8711</name>
      <group>
        <name>Library</name>
        <group>
          <name>api</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\dma_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\flash_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\gpio_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\gpio_irq_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\pinmap.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\pinmap_common.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\port_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\serial_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\sleep.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\sys_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\timer_api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\us_ticker.c</name>
          </file>
        </group>
        <group>
          <name>hal</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_gdma.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_sdr_controller.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_soc_ps_monitor.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\hal_spi_flash_ram.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_timer.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_uart.c</name>
          </file>
        </group>
        <group>
          <name>lib</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\bsp\lib\common\IAR\lib_platform.a</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\bsp\lib\common\IAR\lib_rtlstd.a</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\bsp\lib\va0\rom.a</name>
          </file>
        </group>
        <group>
          <name>rtl8195a</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_gdma.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_ssi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_timer.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_uart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\api\platform\stdlib_patch.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\driver\rtl_consol.c</name>
        </file>
      </group>
      <group>
        <name>Peripherals</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_mcu_powersave.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_rtc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\peripherals\platform_watchdog.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\MCU\RTL8711\platform_init.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\Platform\MCU\mico_platform_common.c</name>
    </file>
  </group>
  <group>
    <name>Support</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Support\CheckSumUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Support\RingBufferUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Support\StringUtils.c</name>
    </file>
  </group>
</project>


